# Keil uVision project Blinky.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Blinky.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX5 5.0.0, CMSIS:RTOS2:Keil RTX5 5.0.0, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:Startup 2.6.0
